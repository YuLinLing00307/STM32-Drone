# Keil uVision project Drone_FlightController.uvprojx, settings and files
target Drone_FlightController (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Drone_FlightController +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/BSP/common;../FreeRTOS/include;../FreeRTOS;../FreeRTOS/portable;../Drivers/APP;../Drivers/INTERFACE;../Drivers/global;../Drivers/INTERFACE/Fix_Height
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c FreeRTOSConfig.h list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/include
    ../FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/portable
    ../FreeRTOS/portable/: heap_4.c port.c portmacro.h
  group global
    ../Drivers/global/: global.c global.h
  group APP
    ../Drivers/APP/: App_FreeRTOS_Task.c App_FreeRTOS_Task.h App_Receive_Data.c App_Receive_Data.h App_Flight.c App_Flight.h
  group INTERFACE
    ../Drivers/INTERFACE/: Int_IP5305T.c Int_IP5305T.h Int_motor.c Int_motor.h Int_led.c Int_led.h Int_SI24R1.c Int_SI24R1.h Int_mpu6050.c Int_mpu6050.h Int_BAT_ADC.c Int_BAT_ADC.h
  group BSP/Common
    ../Drivers/BSP/common/: Com_debug.c Com_debug.h Com_config.h Com_Filter.c Com_Filter.h Com_IMU.c Com_IMU.h Com_PID.c Com_PID.h
  group INTERFACE/Fix_Height
    ../Drivers/INTERFACE/Fix_Height/: vl53l1_platform.c vl53l1_platform.h vl53l1_types.h VL53L1X_api.c VL53L1X_api.h VL53L1X_calibration.c VL53L1X_calibration.h Int_VL53L1X.c Int_VL53L1X.h
software components: CMSIS:CORE 4.3.0
